Commit message: Replace URDF with axol_kit export (ZED cameras, wrist/head mounts)
Swap in the new Onshape axol_kit export as the robot model: adds the ZED
head + wrist cameras, wrist mounts, and head bracket while preserving
everything the control stack depends on. Arm joints keep the *_0 naming
with the hardware-tuned limits (the export ships generic ones), the
*_gripper EE/control frame stays aligned with *_w2 so teleop axes are
unchanged, the actuated prismatic gripper is re-wired, and arm/torso
collision geometry is restored. Cameras/mounts/fasteners are visual-only.

Degenerate connector inertias are sanitized so MuJoCo (gravity comp) can
still load the model. The pink camera FOV/image-plane and misplaced
fisheye-lens visuals are stripped. Also clamp the sim gripper command to
[0, 1] for parity with hardware motion_control.

Co-authored-by: Cursor <cursoragent@cursor.com>

File: almond_axol/kinematics/urdf/axol.urdf (robot description, URDF)
Before this commit: robot assembly, 25 links, 24 joints
Links:
- added link _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1, mass 3.02996e-08; visual mesh filename=package://axol_kit/meshes/_ZED_X_502__ZED_X_50_LCH_asm_din_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 scale=1 1 1
- added link _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1_1, mass 3.02996e-08; visual mesh filename=package://axol_kit/meshes/_ZED_X_502__ZED_X_50_LCH_asm_din_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 scale=1 1 1
- added link _zedx_mini_rev2__lower_case_v13, mass 9.89911e-06; visual mesh filename=package://axol_kit/meshes/_ZEDX_Mini_rev2__Lower_Case_v13.s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 scale=1 1 1
- added link _zedx_mini_rev2__plastron_v2, mass 1.3956e-06; visual mesh filename=package://axol_kit/meshes/_ZEDX_Mini_rev2__Plastron_v2.stl scale=1 1 1
- added link _zedx_mini_rev2__plastron_v2_1, mass 3.81516e-07; visual mesh filename=package://axol_kit/meshes/_ZEDX_Mini_rev2__Plastron_v2_1.stl scale=1 1 1
- added link _zedx_mini_rev2__plastron_v2_2, mass 3.81516e-07; visual mesh filename=package://axol_kit/meshes/_ZEDX_Mini_rev2__Plastron_v2_2.stl scale=1 1 1
- added link _zedx_mini_rev2__upper_case_v8, mass 8.68124e-05; visual mesh filename=package://axol_kit/meshes/_ZEDX_Mini_rev2__Upper_Case_v8.stl scale=1 1 1
- added link bh_tx_mx_xx_xx, mass 8.09335e-08; visual mesh filename=package://axol_kit/meshes/BH_TX_Mx_xx_xx.stl scale=1 1 1
- added link bh_tx_mx_xx_xx_1, mass 8.09335e-08; visual mesh filename=package://axol_kit/meshes/BH_TX_Mx_xx_xx.stl scale=1 1 1
- added link bh_tx_mx_xx_xx_2, mass 8.09335e-08; visual mesh filename=package://axol_kit/meshes/BH_TX_Mx_xx_xx.stl scale=1 1 1
- added link bh_tx_mx_xx_xx_3, mass 8.09335e-08; visual mesh filename=package://axol_kit/meshes/BH_TX_Mx_xx_xx.stl scale=1 1 1
- added link camera_component___body_zed_x_one___front, mass 5.01838e-06; visual mesh filename=package://axol_kit/meshes/Camera_Component___Body_ZED_X_One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 scale=1 1 1
- added link camera_component___body_zed_x_one___front_1, mass 5.01838e-06; visual mesh filename=package://axol_kit/meshes/Camera_Component___Body_ZED_X_One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 scale=1 1 1
- added link camera_component___body_zed_x_one___rear, mass 1.9326e-06; visual mesh filename=package://axol_kit/meshes/Camera_Component___Body_ZED_X_One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 scale=1 1 1
- added link camera_component___body_zed_x_one___rear_1, mass 1.9326e-06; visual mesh filename=package://axol_kit/meshes/Camera_Component___Body_ZED_X_One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 scale=1 1 1
- added link camera_component___connector___fakra_plug, mass 7.34727e-07; visual mesh filename=package://axol_kit/meshes/Camera_Component___Connector___FA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 scale=1 1 1
- added link camera_component___connector___fakra_plug_1, mass 7.34727e-07; visual mesh filename=package://axol_kit/meshes/Camera_Component___Connector___FA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 scale=1 1 1
- added link camera_component___seal___zed_x_one, mass 7.84626e-08; visual mesh filename=package://axol_kit/meshes/Camera_Component___Seal___ZED_X_O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 scale=1 1 1
- added link camera_component___seal___zed_x_one_1, mass 7.84626e-08; visual mesh filename=package://axol_kit/meshes/Camera_Component___Seal___ZED_X_O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 scale=1 1 1
- added link fisheye_lens__1_
- added link fisheye_lens__1__1
- added link head_mount__1_
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_1, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_2, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_3, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_4, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_5, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_6, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_7, mass 4.53311e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_head_cap_screw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 scale=1 1 1
- added link hexalobular_socket_pan_head_screw_iso_14583_m2x5, mass 3.07707e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_pan_head_screw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 scale=1 1 1
- added link hexalobular_socket_pan_head_screw_iso_14583_m2x5_1, mass 3.07707e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_pan_head_screw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 scale=1 1 1
- added link hexalobular_socket_pan_head_screw_iso_14583_m2x5_2, mass 3.07707e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_pan_head_screw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 scale=1 1 1
- added link hexalobular_socket_pan_head_screw_iso_14583_m2x5_3, mass 3.07707e-08; visual mesh filename=package://axol_kit/meshes/Hexalobular_socket_pan_head_screw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 scale=1 1 1
- added link part_1, mass 1.91383e-05; visual mesh filename=package://axol_kit/meshes/Part_1.stl scale=1 1 1
- added link sh_hx_mx_xx_xx, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_1, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_10, mass 1.3323e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_2.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_11, mass 2.35003e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_1.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_12, mass 1.3323e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_2.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_13, mass 2.35003e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_1.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_14, mass 2.35003e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_1.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_15, mass 1.3323e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_2.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_2, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_3, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_4, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_5, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_6, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_7, mass 4.5363e-08; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_8, mass 2.35003e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_1.stl scale=1 1 1
- added link sh_hx_mx_xx_xx_9, mass 1.3323e-07; visual mesh filename=package://axol_kit/meshes/SH_HX_Mx_xx_xx_2.stl scale=1 1 1
- added link wrist_mount, mass 0.0485648; visual mesh filename=package://axol_kit/meshes/Wrist_Mount.stl scale=1 1 1
- added link wrist_mount_1, mass 0.0485648; visual mesh filename=package://axol_kit/meshes/Wrist_Mount.stl scale=1 1 1
- added link wrist_mount__1_
- added link wrist_mount__2_
- added link zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1, mass 1.14537e-11; visual mesh filename=package://axol_kit/meshes/ZED_XG120_ASM_SMB_JACK_TO_FAKRA_P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 scale=1 1 1
- added link zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_1, mass 3.11997e-10; visual mesh filename=package://axol_kit/meshes/ZED_XG120_ASM_SMB_JACK_TO_FAKRA_P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 scale=1 1 1
- added link zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_2, mass 5.4086e-09; visual mesh filename=package://axol_kit/meshes/ZED_XG120_ASM_SMB_JACK_TO_FAKRA_P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 scale=1 1 1
- added link zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_3, mass 7.34727e-07; visual mesh filename=package://axol_kit/meshes/ZED_XG120_ASM_SMB_JACK_TO_FAKRA_P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 scale=1 1 1
- added link zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_4, mass 2.1971e-09; visual mesh filename=package://axol_kit/meshes/ZED_XG120_ASM_SMB_JACK_TO_FAKRA_P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 scale=1 1 1
- link base: mass 0.02496 -> 0.02652; geometry collision mesh filename=package://axol_kit/meshes/Base.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Base.stl scale=1 1 1
- link left_e1: mass 0.00207775 -> 5.60993; geometry collision mesh filename=package://axol_kit/meshes/Left_E1.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_E1.stl scale=1 1 1
- link left_e2: mass 0.000797087 -> 2.15214; geometry collision mesh filename=package://axol_kit/meshes/Left_E2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_E2.stl scale=1 1 1
- link left_gripper_body: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Base.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Base.stl scale=1 1 1
- link left_gripper_finger_a: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1
- link left_gripper_finger_b: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1
- link left_s2: mass 0.00108759 -> 2.9365; geometry collision mesh filename=package://axol_kit/meshes/Left_S2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_S2.stl scale=1 1 1
- link left_s3: mass 0.000265068 -> 2.08078; geometry collision mesh filename=package://axol_kit/meshes/Left_S3.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_S3.stl scale=1 1 1
- link left_w0: mass 0.0005018 -> 1.35486; geometry collision mesh filename=package://axol_kit/meshes/Left_W0.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_W0.stl scale=1 1 1
- link left_w1: mass 0.000330643 -> 0.892737; geometry collision mesh filename=package://axol_kit/meshes/Left_W1.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_W1.stl scale=1 1 1
- link left_w2: mass 4.33287e-05 -> 0.116987; geometry collision mesh filename=package://axol_kit/meshes/Left_W2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Left_W2.stl scale=1 1 1
- link right_e1: mass 0.00207775 -> 5.60993; geometry collision mesh filename=package://axol_kit/meshes/Right_E1.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_E1.stl scale=1 1 1
- link right_e2: mass 0.000797087 -> 2.15214; geometry collision mesh filename=package://axol_kit/meshes/Right_E2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_E2.stl scale=1 1 1
- link right_gripper_body: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Base.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Base.stl scale=1 1 1
- link right_gripper_finger_a: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1
- link right_gripper_finger_b: geometry collision mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Gripper_Tip.stl scale=1 1 1
- link right_s2: mass 0.00108759 -> 2.9365; geometry collision mesh filename=package://axol_kit/meshes/Right_S2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_S2.stl scale=1 1 1
- link right_s3: mass 0.000265068 -> 2.08078; geometry collision mesh filename=package://axol_kit/meshes/Right_S3.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_S3.stl scale=1 1 1
- link right_w0: mass 0.0005018 -> 1.35486; geometry collision mesh filename=package://axol_kit/meshes/Right_W0.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_W0.stl scale=1 1 1
- link right_w1: mass 0.000330643 -> 0.892737; geometry collision mesh filename=package://axol_kit/meshes/Right_W1.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_W1.stl scale=1 1 1
- link right_w2: mass 4.33287e-05 -> 0.116987; geometry collision mesh filename=package://axol_kit/meshes/Right_W2.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/Right_W2.stl scale=1 1 1
- link s1: mass 0.003744 -> 0.00374359; geometry collision mesh filename=package://axol_kit/meshes/S1.stl scale=1 1 1; visual mesh filename=package://axol_kit/meshes/S1.stl scale=1 1 1
Joints:
- removed joint base_0
- removed joint fixed_node_to_root_joint_0
- added joint base: type fixed, parent s1, child base, origin xyz=-0.0212132 0.0137132 -0.12 rpy=0 1.06752e-16 0, axis 1.06752e-16 0 1
- added joint fastened_1: type fixed, parent wrist_mount_1, child camera_component___body_zed_x_one___front_1, origin xyz=0.02 -0.00802438 0.0582209 rpy=2.70526 -2.38974e-16 -3.14159, axis -0 -1 -0
- added joint fastened_1_1: type fixed, parent part_1, child _zedx_mini_rev2__lower_case_v13, origin xyz=0.0397132 -0.0715941 -0.0307218 rpy=-0.349066 4.20261e-16 -3.14159, axis 0 0 1
- added joint fastened_1_2: type fixed, parent part_1, child s1, origin xyz=0.0424264 0.00243219 -0.00204085 rpy=0.872665 8.85932e-18 2.45965e-16, axis -1.06752e-16 -0 1
- added joint fastened_1_3: type fixed, parent wrist_mount, child camera_component___body_zed_x_one___front, origin xyz=0.02 -0.00802438 0.0582209 rpy=2.70526 -2.38974e-16 -3.14159, axis -0 -1 -0
- added joint fastened_2: type fixed, parent wrist_mount_1, child wrist_mount__1_, origin xyz=0.02 -2.77556e-17 -0.0285001 rpy=-1.2326e-32 1.2178e-41 -7.50526e-74, axis -0 1 -0
- added joint fastened_2_1: type fixed, parent wrist_mount, child wrist_mount__2_, origin xyz=0.02 1.38778e-16 -0.0285001 rpy=5.68515e-14 4.29527e-30 6.31089e-30, axis -0 1 -0
- added joint fastened_2_2: type fixed, parent left_gripper_body, child wrist_mount, origin xyz=-0.02 -0.045 0.0285 rpy=-2.02816e-15 -2.61077e-29 -9.48894e-15, axis 0 -1 0
- added joint fastened_3: type fixed, parent wrist_mount_1, child sh_hx_mx_xx_xx_7, origin xyz=0.0095 -0.00646442 0.0473628 rpy=2.00713 2.36935e-30 -9.9436e-30, axis -0 -0 -1
- added joint fastened_3_1: type fixed, parent wrist_mount_1, child sh_hx_mx_xx_xx_6, origin xyz=0.0305 -0.00646442 0.0473628 rpy=2.00713 2.36935e-30 -9.9436e-30, axis -0 -0 -1
- added joint fastened_3_10: type fixed, parent wrist_mount, child sh_hx_mx_xx_xx_1, origin xyz=0.0305 -0.00646442 0.0473628 rpy=2.00713 8.78043e-30 -5.34531e-30, axis -0 -0 -1
- added joint fastened_3_11: type fixed, parent wrist_mount, child sh_hx_mx_xx_xx_3, origin xyz=0.0095 -0.0153394 0.0663953 rpy=2.00713 8.78043e-30 -5.34531e-30, axis -0 -0 -1
- added joint fastened_3_12: type fixed, parent wrist_mount, child sh_hx_mx_xx_xx_2, origin xyz=0.0305 -0.0153394 0.0663953 rpy=2.00713 8.78043e-30 -5.34531e-30, axis -0 -0 -1
- added joint fastened_3_2: type fixed, parent wrist_mount_1, child sh_hx_mx_xx_xx_5, origin xyz=0.0095 -0.0153394 0.0663953 rpy=2.00713 2.36935e-30 -9.9436e-30, axis -0 -0 -1
- added joint fastened_3_3: type fixed, parent wrist_mount_1, child sh_hx_mx_xx_xx_4, origin xyz=0.0305 -0.0153394 0.0663953 rpy=2.00713 2.36935e-30 -9.9436e-30, axis -0 -0 -1
- added joint fastened_3_4: type fixed, parent right_gripper_body, child wrist_mount_1, origin xyz=-0.02 -0.045 0.0285 rpy=-2.02816e-15 -1.74249e-29 -9.48894e-15, axis 0 -1 0
- added joint fastened_3_5: type fixed, parent part_1, child sh_hx_mx_xx_xx_14, origin xyz=0.0397132 -0.0867754 -0.0328686 rpy=-0.349066 1.62899e-16 -3.14159, axis -0 -0 -1
- added joint fastened_3_6: type fixed, parent part_1, child sh_hx_mx_xx_xx_8, origin xyz=0.0027132 -0.0726801 -0.0277383 rpy=-0.349066 1.62899e-16 -3.14159, axis -0 -0 -1
- added joint fastened_3_7: type fixed, parent part_1, child sh_hx_mx_xx_xx_13, origin xyz=0.0397132 -0.0726801 -0.0277383 rpy=-0.349066 1.62899e-16 -3.14159, axis -0 -0 -1
- added joint fastened_3_8: type fixed, parent part_1, child sh_hx_mx_xx_xx_11, origin xyz=0.0027132 -0.0867754 -0.0328686 rpy=-0.349066 1.62899e-16 -3.14159, axis -0 -0 -1
- added joint fastened_3_9: type fixed, parent wrist_mount, child sh_hx_mx_xx_xx, origin xyz=0.0095 -0.00646442 0.0473628 rpy=2.00713 8.78043e-30 -5.34531e-30, axis -0 -0 -1
- added joint fastened_4: type fixed, parent wrist_mount_1, child bh_tx_mx_xx_xx_3, origin xyz=-1.11022e-16 0.003175 -6.93889e-18 rpy=-1.5708 9.46633e-30 7.64394e-30, axis -0 -0 -1
- added joint fastened_4_1: type fixed, parent wrist_mount_1, child bh_tx_mx_xx_xx_2, origin xyz=0.04 0.003175 -1.04083e-17 rpy=-1.5708 9.46633e-30 7.64394e-30, axis -0 -0 -1
- added joint fastened_4_2: type fixed, parent part_1, child sh_hx_mx_xx_xx_9, origin xyz=0.0424264 -2.22045e-15 -6.66134e-16 rpy=0.872665 -1.84577e-16 3.2691e-16, axis -0 -0 -1
- added joint fastened_4_3: type fixed, parent part_1, child sh_hx_mx_xx_xx_15, origin xyz=0.0424264 0.0272712 0.0325005 rpy=0.872665 -1.84577e-16 3.2691e-16, axis -0 -0 -1
- added joint fastened_4_4: type fixed, parent part_1, child sh_hx_mx_xx_xx_12, origin xyz=-2.15106e-16 0.0272712 0.0325005 rpy=0.872665 -1.84577e-16 3.2691e-16, axis -0 -0 -1
- added joint fastened_4_5: type fixed, parent sh_hx_mx_xx_xx_10, child part_1, origin xyz=2.08167e-16 1.87871e-15 -1.22125e-15 rpy=-0.872665 -2.98603e-17 -1.74992e-16, axis 0 -0.766044 0.642788
- added joint fastened_4_6: type fixed, parent wrist_mount, child bh_tx_mx_xx_xx, origin xyz=0 0.003175 -1.60982e-15 rpy=-1.5708 4.29527e-30 1.35364e-29, axis -0 -0 -1
- added joint fastened_4_7: type fixed, parent wrist_mount, child bh_tx_mx_xx_xx_1, origin xyz=0.04 0.003175 -1.61676e-15 rpy=-1.5708 4.29527e-30 1.35364e-29, axis -0 -0 -1
- added joint fastened_5: type fixed, parent part_1, child head_mount__1_, origin xyz=0.0212132 0.0160678 0.0142094 rpy=0.872665 -8.96395e-17 2.46283e-16, axis 0 0 1
- added joint group_1_fastened_joint: type fixed, parent hexalobular_socket_pan_head_screw_iso_14583_m2x5_3, child hexalobular_socket_pan_head_screw_iso_14583_m2x5_2, origin xyz=0 2.77556e-17 0.0136 rpy=0 -0 5.55112e-17, axis 0 0 1
- added joint group_1_fastened_joint_1: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_5, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_7, origin xyz=2.77556e-17 2.77556e-17 -0.021 rpy=-1.57772e-30 1.2446e-60 1.57772e-30, axis 0 0 1
- added joint group_1_fastened_joint_10: type fixed, parent zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_4, child zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_1, origin xyz=0 -5.91646e-31 0 rpy=-1.97215e-31 -5.55112e-17 1.47911e-31, axis 0 0 1
- added joint group_1_fastened_joint_11: type fixed, parent _zedx_mini_rev2__lower_case_v13, child _zedx_mini_rev2__upper_case_v8, origin xyz=0.00589979 -0.00173896 -0.00564672 rpy=1.21543e-63 -4.93038e-32 -4.93038e-32, axis -0 -0 -1
- added joint group_1_fastened_joint_12: type fixed, parent _zedx_mini_rev2__plastron_v2_2, child _zedx_mini_rev2__plastron_v2_1, origin xyz=1.73472e-18 0 0 rpy=1.21543e-63 -4.93038e-32 -4.93038e-32, axis -0 -0 -1
- added joint group_1_fastened_joint_13: type fixed, parent _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1, child zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_4, origin xyz=0.0068 -6.66134e-16 0.00227 rpy=3.14159 -2.37701e-17 -1.5708, axis 0 0 1
- added joint group_1_fastened_joint_14: type fixed, parent _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1_1, child _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1, origin xyz=-0.0136 -1.11022e-16 0 rpy=8.50803e-63 9.86076e-32 1.72563e-31, axis 0 0 1
- added joint group_1_fastened_joint_15: type fixed, parent _zedx_mini_rev2__lower_case_v13, child zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_2, origin xyz=0.0185 0.00337099 -0.00067 rpy=-5.26365e-15 2.37701e-17 1.5708, axis 0 0 1
- added joint group_1_fastened_joint_16: type fixed, parent _zedx_mini_rev2__upper_case_v8, child _zedx_mini_rev2__plastron_v2_2, origin xyz=1.1389e-05 0 -6.66134e-16 rpy=1.21543e-63 -4.93038e-32 -4.93038e-32, axis -0 -0 -1
- added joint group_1_fastened_joint_17: type fixed, parent zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_2, child zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1, origin xyz=0 -5.91646e-31 0 rpy=-1.97215e-31 -5.55112e-17 1.47911e-31, axis 0 0 1
- added joint group_1_fastened_joint_18: type fixed, parent zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_1, child zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1_3, origin xyz=0.000250214 0.000307387 0.000641526 rpy=-1.97215e-31 -5.55112e-17 1.47911e-31, axis 0 0 1
- added joint group_1_fastened_joint_19: type fixed, parent _zedx_mini_rev2__plastron_v2_1, child _zedx_mini_rev2__plastron_v2, origin xyz=1.73472e-18 0 0 rpy=1.21543e-63 -4.93038e-32 -4.93038e-32, axis -0 -0 -1
- added joint group_1_fastened_joint_2: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_4, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_5, origin xyz=2.77556e-17 0.021 0.021 rpy=-1.57772e-30 1.2446e-60 1.57772e-30, axis 0 0 1
- added joint group_1_fastened_joint_20: type fixed, parent zed_xg120_asm_smb_jack_to_fakra_plug_adapter_v1, child _zed_x_502__zed_x_50_lch_asm_din_en_iso7045_m2x5_4_8h_v1_1, origin xyz=-5.55112e-16 -0.0068 0.00227 rpy=-3.14159 5.20814e-15 -1.5708, axis 0 0 1
- added joint group_1_fastened_joint_21: type fixed, parent hexalobular_socket_pan_head_screw_iso_14583_m2x5_1, child hexalobular_socket_pan_head_screw_iso_14583_m2x5, origin xyz=0 8.32667e-17 0.0136 rpy=1.38778e-17 -1.38778e-17 2.77556e-17, axis 0 0 1
- added joint group_1_fastened_joint_22: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_3, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_1, origin xyz=0 1.38778e-16 -0.021 rpy=-1.57772e-30 0 0, axis 0 0 1
- added joint group_1_fastened_joint_23: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_2, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_3, origin xyz=-2.77556e-17 0.021 0.021 rpy=-1.57772e-30 0 0, axis 0 0 1
- added joint group_1_fastened_joint_24: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_1, child hexalobular_socket_pan_head_screw_iso_14583_m2x5_1, origin xyz=-0.00497 -0.0137181 0.00124526 rpy=-1.08088 1.74863e-16 8.32299e-18, axis 0 0 1
- added joint group_1_fastened_joint_25: type fixed, parent fisheye_lens__1_, child camera_component___seal___zed_x_one, origin xyz=1.66533e-16 -3.57353e-16 -0.0121 rpy=-9.33452e-60 -4.73317e-30 3.9443e-30, axis -0 -0 -1
- added joint group_1_fastened_joint_26: type fixed, parent camera_component___body_zed_x_one___rear, child camera_component___connector___fakra_plug, origin xyz=-0.002782 -0.006055 0.00193 rpy=1.5708 -7.77156e-16 1.08088, axis 0 0 1
- added joint group_1_fastened_joint_27: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_2, origin xyz=-2.77556e-17 1.11022e-16 -0.021 rpy=-1.57772e-30 0 0, axis 0 0 1
- added joint group_1_fastened_joint_28: type fixed, parent camera_component___body_zed_x_one___front, child camera_component___body_zed_x_one___rear, origin xyz=5.55112e-17 0.02022 -5.55112e-17 rpy=-1.5708 3.94353e-30 1.21431e-17, axis 0 0 1
- added joint group_1_fastened_joint_29: type fixed, parent camera_component___connector___fakra_plug, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10, origin xyz=0.0208575 -0.0043 0.00392973 rpy=-2.06071 5.55112e-17 -1.5708, axis 0 0 1
- added joint group_1_fastened_joint_3: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_7, child hexalobular_socket_pan_head_screw_iso_14583_m2x5_3, origin xyz=-0.00497 -0.0137181 0.00124526 rpy=-1.08088 1.44331e-16 -1.11055e-17, axis 0 0 1
- added joint group_1_fastened_joint_30: type fixed, parent camera_component___body_zed_x_one___front, child fisheye_lens__1_, origin xyz=-5.55112e-17 0 -6.93889e-18 rpy=-1.5708 2.63678e-16 3.14159, axis -0 -0 -1
- added joint group_1_fastened_joint_4: type fixed, parent fisheye_lens__1__1, child camera_component___seal___zed_x_one_1, origin xyz=1.11022e-16 -3.22659e-16 -0.0121 rpy=6.22302e-61 1.57772e-30 7.88861e-31, axis -0 -0 -1
- added joint group_1_fastened_joint_5: type fixed, parent camera_component___body_zed_x_one___rear_1, child camera_component___connector___fakra_plug_1, origin xyz=-0.002782 -0.006055 0.00193 rpy=1.5708 -7.77156e-16 1.08088, axis 0 0 1
- added joint group_1_fastened_joint_6: type fixed, parent hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_6, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_4, origin xyz=2.77556e-17 5.55112e-17 -0.021 rpy=-1.57772e-30 1.2446e-60 1.57772e-30, axis 0 0 1
- added joint group_1_fastened_joint_7: type fixed, parent camera_component___body_zed_x_one___front_1, child camera_component___body_zed_x_one___rear_1, origin xyz=8.32667e-17 0.02022 -1.11022e-16 rpy=-1.5708 9.46556e-30 1.21431e-17, axis 0 0 1
- added joint group_1_fastened_joint_8: type fixed, parent camera_component___connector___fakra_plug_1, child hexalobular_socket_head_cap_screw_iso14579_m2x0_4x10_6, origin xyz=0.0208575 -0.0043 0.00392973 rpy=-2.06071 5.55112e-17 -1.5708, axis 0 0 1
- added joint group_1_fastened_joint_9: type fixed, parent camera_component___body_zed_x_one___front_1, child fisheye_lens__1__1, origin xyz=2.77556e-17 -2.77556e-17 6.93889e-18 rpy=-1.5708 2.63678e-16 3.14159, axis -0 -0 -1
- added joint hanging_node_to_root_joint: type fixed, parent root, child sh_hx_mx_xx_xx_10, origin xyz=-0.0212132 -0.0137132 0.973175 rpy=2.69507e-14 -2.20045e-16 1.11943e-16, axis 0 0 1
- joint left_e1_0: limit lower=0.0 upper=2.6180 effort=87.0 velocity=30.0 -> lower=0.0 upper=2.618 effort=87.0 velocity=30.0; origin xyz=0.04229 1.56381e-16 -0.289385 rpy=1.11022e-16 -4.93529e-16 -6.92805e-17 -> xyz=0.04229 3.83668e-17 -0.289385 rpy=6.27582e-14 1.30104e-17 5.77135e-18
- joint left_e2_0: origin xyz=-0.04229 -1.48698e-17 -0.12429 rpy=-8.32667e-17 -6.33174e-17 7.22079e-17 -> xyz=-0.04229 -7.12753e-18 -0.12429 rpy=-3.2474e-15 -6.33174e-17 -2.54576e-14
- joint left_s1_0: origin xyz=0.13 9.40122e-18 0.06 rpy=2.77556e-17 -1.02798e-15 1.32751e-21 -> xyz=0.108787 0.0137132 -0.06 rpy=6.43813e-31 -9.66752e-16 8.11935e-28
- joint left_s2_0: origin xyz=0.06958 -0.04475 4.44089e-16 rpy=2.498e-16 3.92274e-16 -2.48934e-16 -> xyz=0.06958 -0.04475 3.33067e-16 rpy=-8.54059e-31 1.28437e-14 -1.22465e-16
- joint left_s3_0: origin xyz=-1.91513e-15 0.04475 -0.07335 rpy=3.33067e-16 -1.05818e-16 -2.03288e-16 -> xyz=-3.88578e-16 0.04475 -0.07335 rpy=5.06891e-29 6.12323e-17 -7.93161e-15
- joint left_w1_0: origin xyz=-5.55112e-17 -0.0285 -0.13567 rpy=-4.71845e-16 3.45904e-15 -1.18829e-15 -> xyz=-8.32667e-17 -0.0285 -0.13567 rpy=-4.2466e-15 1.76757e-14 2.71935e-15
- joint left_w2_0: origin xyz=0.0285 0.0285 -0.057 rpy=3.4972e-15 -8.32667e-17 -9.70669e-32 -> xyz=0.0285 0.0285 -0.057 rpy=-2.21714e-14 1.79213e-44 1.61661e-30
- joint right_e1_0: limit lower=-2.6180 upper=0.0 effort=87.0 velocity=30.0 -> lower=-2.618 upper=0.0 effort=87.0 velocity=30.0; origin xyz=-0.04229 1.47751e-17 -0.289385 rpy=1.07561e-45 7.39557e-32 1.84889e-32 -> xyz=-0.04229 1.60479e-17 -0.289385 rpy=-6.12323e-17 6.12323e-17 -6.12323e-17
- joint right_e2_0: origin xyz=0.04229 -5.37817e-17 -0.12429 rpy=7.66335e-47 -2.46519e-32 3.14159 -> xyz=0.04229 -3.11655e-17 -0.12429 rpy=1.61476e-27 -7.92016e-28 -3.14159
- joint right_s1_0: origin xyz=-0.13 2.46215e-18 0.06 rpy=-4.76873e-49 -2.31296e-16 7.65788e-33 -> xyz=-0.151213 0.0137132 -0.06 rpy=-2.27247e-31 -2.31296e-16 7.35455e-16
- joint right_s2_0: origin xyz=-0.06958 -0.04475 4.44089e-16 rpy=-1.28654e-32 -9.17877e-18 -7.824e-17 -> xyz=-0.06958 -0.04475 4.44089e-16 rpy=-5.61996e-30 -1.32163e-14 -3.9443e-31
- joint right_s3_0: origin xyz=3.88578e-16 0.04475 -0.07335 rpy=-1.08655e-45 -1.28919e-43 -6.16298e-33 -> xyz=4.16334e-16 0.04475 -0.07335 rpy=-2.235e-28 1.07364e-27 -3.41903e-14
- joint right_w1_0: origin xyz=1.11022e-16 0.0285 -0.13567 rpy=1.09476e-47 2.55312e-94 -4.66423e-47 -> xyz=1.66533e-16 0.0285 -0.13567 rpy=9.03554e-29 -4.3255e-14 -4.98658e-30
- joint right_w2_0: origin xyz=0.0285 -0.0285 -0.057 rpy=-3.73315e-45 -4.43734e-31 3.14159 -> xyz=0.0285 -0.0285 -0.057 rpy=-8.07794e-27 1.05707e-27 -3.14159
